# Keil uVision project digital.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC10F04XE STC10F04XE Series
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0xFFF) CLOCK(45000000) MODP2
  output: led +hex
  c flags: Optimize=9
  group Source Group 1
    ./: main.c
